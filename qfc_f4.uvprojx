# Keil uVision project qfc_f4.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F427VI STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: qfc_f4
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, USE_FULL_ASSERT, HSE_VALUE=24000000
  c misc: --c99 -O1 -g -W
  c include: .\src\lib\STM32F4xx_StdPeriph_Driver\CMSIS\Include;.\src\lib\STM32F4xx_StdPeriph_Driver\inc;.\src\main;.\src\main\target\qfc_alfa2.0;.\src\main\build;.\src\main\common;.\src\main\config;.\src\main\drivers;.\src\main\apps;.\src\lib\MAVLink
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group target
    ./src/main/target/qfc_alfa2.0/: target.c target.h
    ./src/main/: platform.h
  group build
    ./src/main/build/: atomic.c build_config.c debug.c version.c
  group common
    ./src/main/common/: printf.c bitarray.c encoding.c maths.c bitops.c filter.c explog_approx.c time.c typeconversion.c streambuf.c gps_conversion.c
  group config
    ./src/main/config/: feature.c config_eeprom.c
  group drivers
    ./src/main/drivers/: io.c dma_stm32f4xx.c light_led.c rcc.c resource.c serial.c serial_pinconfig.c serial_uart.c serial_uart_init.c serial_uart_pinconfig.c serial_uart_stm32f4xx.c system.c system_stm32f4.c bus_spi_config.c sound_beeper.c adc.c adc_stm32f4xx.c buf_writer.c bus.c bus_i2c_busdev.c bus_i2c_config.c bus_spi.c bus_spi_pinconfig.c bus_spi_stdperiph.c buttons.c exti.c inverter.c pinio.c pwm_output.c pwm_output_dshot.c timer.c timer_stm32f4xx.c bus_i2c_stm32f10x_4x.c stack_check.c
    ./src/main/drivers/rx/: rx_pwm.c
    ./src/main/drivers/rangefinder/: rangefinder_hcsr04.c rangefinder_lidartf.c
  group pg
    ./src/main/drivers/pg/: adc.c beeper.c beeper_dev.c bus_i2c.c flash.c pg.c rx_pwm.c bus_spi.c dashboard.c max7456.c piniobox.c sdcard.c vcd.c
  group fc
    ./src/main/: main.c
    ./src/main/apps/fc/: fc_init.c config.c controlrate_profile.c fc_core.c fc_dispatch.c fc_hardfaults.c fc_rc.c fc_tasks.c rc_adjustments.c rc_controls.c rc_modes.c runtime_config.c
  group io
    ./src/main/drivers/io/: beeper.c gps.c ledstrip.c serial.c statusindicator.c
  group sensors
    ./src/main/drivers/sensors/: acceleration.c adcinternal.c barometer.c battery.c boardalignment.c compass.c current.c esc_sensor.c gyro.c initialisation.c rangefinder.c voltage.c
  group flight
    ./src/main/apps/flight/: altitude.c failsafe.c imu.c mixer.c navigation.c pid.c servos.c
  group rx
    ./src/main/rx/: sbus.c rx.c pwm.c msp.c sbus_channels.c
  group sheduler
    ./src/main/apps/scheduler/: scheduler.c
  group interface
    ./src/main/drivers/interface/: cli.c msp.c msp_box.c settings.c
  group msp
    ./src/main/drivers/msp/: msp_serial.c
  group accgyro
    ./src/main/drivers/accgyro/: gyro_sync.c accgyro_mpu.c accgyro_fake.c accgyro_spi_mpu9250.c accgyro_spi_mpu6000.c accgyro_bma280.c
  group barometer
    ./src/main/drivers/barometer/: barometer_bmp280.c barometer_ms5611.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:ADC 1.3.0, Device:StdPeriph Drivers:DMA 1.3.0, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:I2C 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:SPI 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
